# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Demo +hex
  AfterMake: .\Release\make.bat
  c flags: Optimize=8
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User;..\..\Hardware;..\..\App
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c debug.c
  group Hardware
    ../../Hardware/: motor.c tmr1.c tmr2.c adc.c key.c led.c
  group App
    ../../App/: charge.c heating.c
  group User
    ../../User/: main.c
